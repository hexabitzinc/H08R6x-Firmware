# Keil uVision project H08R6.uvprojx, settings and files
target Module 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F091CBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Module 1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F091xB,H08R6,_module=1,USE_I2C_2V8
  c include: ..\User;..\H08R6;..\BOS;..\Thirdparty\Middleware\FreeRTOS\Source\CMSIS_RTOS;..\Thirdparty\Middleware\FreeRTOS\Source\include;..\Thirdparty\Middleware\FreeRTOS\Source\portable\RVDS\ARM_CM0;..\Thirdparty\STM32F0xx_HAL_Driver\Inc\Legacy;..\Thirdparty\STM32F0xx_HAL_Driver\Inc;..\Thirdparty\CMSIS\Device\ST\STM32F0xx\Include;..\Thirdparty\CMSIS\Include;..\Thirdparty\VL53L0X_1.0.2\Api\core\inc;..\Thirdparty\VL53L0X_1.0.2\Api\platform\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ../User/: main.c
  group CMSIS
    ../thirdparty/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group STM32F0xx_HAL_Driver
    ../thirdparty/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c
    ../Thirdparty/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c
  group BITZ/BOS
    ../BOS/: BOS.c BOS_CLI.c BOS_eeprom.c BOS_freertos.c
  group BITZ/H08R6
    ../H08R6/: H08R6.c H08R6_dma.c H08R6_gpio.c H08R6_it.c H08R6_uart.c H08R6_i2c.c startup_stm32f091xc.s
  group FreeRTOS
    ../thirdparty/Middleware/FreeRTOS/Source/: croutine.c event_groups.c FreeRTOS_CLI.c list.c queue.c tasks.c timers.c
    ../thirdparty/Middleware/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    ../thirdparty/Middleware/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../thirdparty/Middleware/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group VL53L0X
    ../Thirdparty/VL53L0X_1.0.2/Api/core/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
    ../Thirdparty/VL53L0X_1.0.2/Api/platform/src/: vl53l0x_platform.c
target Module 2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F091CBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: as above
  output: Module 2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F091xB,H08R6,_module=2,USE_I2C_2V8
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target Module 3 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F091CBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: as above
  output: Module 3 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F091xB,H08R6,_module=3,USE_I2C_2V8
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target Module 4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F091CBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: as above
  output: Module 4 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F091xB,H08R6,_module=4,USE_I2C_2V8
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target Module 5 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F091CBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: as above
  output: Module 5 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F091xB,H08R6,_module=5,USE_I2C_2V8
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target Module 6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F091CBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: as above
  output: Module 6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F091xB,H08R6,_module=6,USE_I2C_2V8
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target Module 7 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F091CBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: as above
  output: Module 7 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F091xB,H08R6,_module=7,USE_I2C_2V8
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
